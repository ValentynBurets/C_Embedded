# Keil uVision project Lab1_SPL_EEPROM.uvprojx, settings and files
target I2C_EEPROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1_SPL_EEPROM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40XX
  c include: ..\Shared\SPL\STM32F4xx_StdPeriph_Driver\inc;..\PM_Lab1_SPL;..\Shared\SPL\CMSIS\Device\ST\STM32F4xx\Include;..\Shared\SPL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: main.h main.c
  group SPL
    ../Shared/SPL/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_gpio.c
  group CMSIS
    ../Shared/SPL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../Shared/SPL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers
    ./: Driver_I2C.h Driver_I2C.c
  group Utilities
    ./: delay.h delay.c
  group eeprom
    ./: eeprom.c eeprom.h
